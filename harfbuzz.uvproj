# Keil uVision project harfbuzz.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-R4F ARM
  cpu: CLOCK(160000000) CPUTYPE("Cortex-R4F") ESEL EBIG
  output: harfbuzz (library)
  c flags: OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: HB_NO_MT HAVE_OT HAVE_ICU HAVE_ICU_BUILTIN
  c misc: --arm
  c include: .\src
  group Source Group 1
    ./src/: hb-buffer-serialize.cc hb-buffer.cc hb-common.cc hb-face.cc hb-font.cc hb-ot-tag.cc hb-set.cc hb-shape.cc hb-shape-plan.cc hb-shaper.cc hb-unicode.cc hb-warning.cc hb-ot-font.cc hb-ot-layout.cc hb-ot-map.cc hb-ot-math.cc hb-ot-shape.cc hb-ot-shape-complex-arabic.cc hb-ot-shape-complex-default.cc hb-ot-shape-complex-hangul.cc hb-ot-shape-complex-hebrew.cc hb-ot-shape-complex-indic.cc hb-ot-shape-complex-indic-table.cc hb-ot-shape-complex-myanmar.cc hb-ot-shape-complex-thai.cc hb-ot-shape-complex-tibetan.cc hb-ot-shape-complex-use.cc hb-ot-shape-complex-use-table.cc hb-ot-shape-normalize.cc hb-ot-shape-fallback.cc hb-ot-var.cc hb-blob.cc hb-icu.cc
